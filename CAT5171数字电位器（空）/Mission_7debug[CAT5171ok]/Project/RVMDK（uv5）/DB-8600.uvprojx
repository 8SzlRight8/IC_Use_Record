# Keil uVision project DB-8600.uvprojx, settings and files
target Mission_2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Mission_3_LaoLian +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,LV_CONF_INCLUDE_SIMPLE,NDEBUG
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4_Driver\inc;..\..\src;..\..\INCLUDE;..\..\HARDWARE;..\..\HARDWARE\usart;..\..\HARDWARE\led;..\..\HARDWARE\gpio;..\..\HARDWARE\sdram;..\..\HARDWARE\dac;..\..\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: ..\..\Output\Mission_2.sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
    ../../include/: stm32f4xx_conf.h
  group STM32F4_Driver
    ../../Libraries/STM32F4_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fmc.c stm32f4xx_adc.c stm32f4xx_flash.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_dac.c stm32f4xx_spi.c stm32f4xx_iwdg.c stm32f4xx_dma.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group src
    ../../src/: main.c
    ../../HARDWARE/usart/: bsp_rs232_usart.c
    ../../HARDWARE/: bsp_general_tim.c bsp_advance_tim.c digital_i2c.c bsp_i2c_gpio.c
    ../../HARDWARE/sdram/: bsp_sdram.c
    ../../HARDWARE/gpio/: gpio.c
    ../../HARDWARE/dac/: bsp_dac.c
  group INCLUDE
    ../../include/: VAR.h define.h ExtVar.h
